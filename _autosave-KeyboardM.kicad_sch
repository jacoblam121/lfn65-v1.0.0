File: _autosave-KeyboardM.kicad_sch (KiCad schematic)
At the start: 21 parts, among them U1 ATmega32U4-A

Commit message: Switch Matrix
Other:
- added sheet matrix (matrix.kicad_sch)
